# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB,USBD_SUPPORT_USER_STRING_DESC
  c misc: --diag_suppress=186,66
  c include: ..\usb_lib\usb_core;..\usb_lib\device_core;..\mcu\common;..\source;..\driver\inc;..\usb_lib\device_class\cdc_msc_composite;..\w25qxx\inc;..\usb_lib\device_class\single_cdc;..\usb_lib\device_class\msc;..\bsp\ev_hc32f460_lqfp100_v1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ../mcu/common/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: hc32f460_pwc.c hc32f460_clk.c hc32f460_keyscan.c hc32f460_utility.c hc32f460_sram.c hc32f460_icg.c hc32f460_usart.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_interrupts.c hc32f460_efm.c hc32f460_qspi.c
  group ev_hc32f460_lqfp100_v1
    ../bsp/ev_hc32f460_lqfp100_v1/: ev_hc32f460_lqfp100_v1.c
  group usb_lib
    ../usb_lib/usb_core/: usb_core_driver.c
    ../usb_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
  group cdc_msc
    ../source/: usb_bsp.c usb_dev_desc.c usb_dev_msc_msd.c usb_dev_user.c
    ../usb_lib/device_class/single_cdc/: usb_dev_cdc_class.c
    ../usb_lib/device_class/msc/: usb_dev_msc_bot.c usb_dev_msc_class.c usb_dev_msc_data.c usb_dev_msc_scsi.c
    ../usb_lib/device_class/cdc_msc_composite/: usb_dev_cdc_msc_wrapper.c
  group Readme
    ../: Readme.txt
  group W25Qxx
    ../w25qxx/src/: w25qxx.c
target template_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.1.0
